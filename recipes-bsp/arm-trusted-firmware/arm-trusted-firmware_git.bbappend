COMPATIBLE_MACHINE .= "|raptor|v4h-sbc|hel"
