COMPATIBLE_MACHINE = "raptor"
