COMPATIBLE_MACHINE = "raptor|sparrowhawk"
