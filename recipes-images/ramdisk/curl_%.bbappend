PACKAGECONFIG_append += " smb"
PACKAGECONFIG_append += " smtp"
PACKAGECONFIG_append += " rtsp"
