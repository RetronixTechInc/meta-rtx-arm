# look for files in the layer first
#FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

RRECOMMENDS_e2fsprogs = "e2fsprogs-e2fsck e2fsprogs-mke2fs e2fsprogs-tune2fs e2fsprogs-badblocks e2fsprogs-resize2fs"
