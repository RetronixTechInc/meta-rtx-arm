
SRC_URI = "git://github.com/cisco/libsrtp.git;protocol=https;branch=1_5_x_throttle \
           file://0001-Rename-conflicting-variable-mips.patch \
           "

