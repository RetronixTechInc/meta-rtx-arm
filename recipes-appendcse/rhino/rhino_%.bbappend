
SRC_URI = "\
	https://github.com/mozilla/rhino/releases/download/Rhino1_7R4_RELEASE/rhino1_7R4.zip \
	file://rhino \
	file://rhino-jsc \
	"

