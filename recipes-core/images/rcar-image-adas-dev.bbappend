COMPATIBLE_MACHINE = "raptor"

IMAGE_INSTALL:append = " \
	packagegroup-burnin-tools \
	packagegroup-network-tools \
	spidev-test \
"
