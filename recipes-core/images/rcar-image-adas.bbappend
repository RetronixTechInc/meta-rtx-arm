COMPATIBLE_MACHINE = "raptor"

IMAGE_INSTALL:append = " \
	spidev-test \
"
