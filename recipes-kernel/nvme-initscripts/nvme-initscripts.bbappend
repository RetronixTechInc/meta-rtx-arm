COMPATIBLE_MACHINE = "(whitehawk|raptor)"
