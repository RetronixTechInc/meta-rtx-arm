COMPATIBLE_MACHINE = "raptor|whitehawk|grayhawk"
